# Keil uVision project BUTTON.uvproj, settings and files
target ONE (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: BUTTON +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Include;..\Common;..\Startup;..\Startup
  group Source
    ./: main.c
  group Common
    ../Common/: Delay.c Common.c
